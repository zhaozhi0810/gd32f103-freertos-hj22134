# Keil uVision project hj22134-gd32f103-freertos.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103VB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hj22134-gd32f103-freertos +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src\freertos\include;.\src;.\src\freertos\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user_apps
    ./src/: main.c led_show_work.c
  group freertos
    ./src/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./src/freertos/portable/RVDS/ARM_CM3/: port.c
    ./src/freertos/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.3.0, Device:GD32F10x_StdPeripherals:GPIO 2.0.1, Device:GD32F10x_StdPeripherals:MISC 2.0.1, Device:GD32F10x_StdPeripherals:PMU 2.0.1, Device:GD32F10x_StdPeripherals:RCU 2.0.1, Device:GD32F10x_libopt 2.0.1, Device:Startup 2.0.1
